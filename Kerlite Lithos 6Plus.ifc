Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement[Architecture]
File name: F:/BIM PGR/BIM COTTO D'ESTE/LITHOS/kerlite lithos/Kerlite Lithos 6Plus.ifc
Time: 2020-10-30T11:21:50
Author: Architect
Organization: Nemetschek Vectorworks, Inc.
Written by: Vectorworks Architect 2021 SP1 R1 (Build 568598) (64-Bit) by Vectorworks, Inc.
Made in: Windows

# IfcSite, Sito standard
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0

# IfcBuilding, Edificio standard
Pset_BuildingCommon - SprinklerProtection: no; SprinklerProtectionAutomatic: no; NumberOfStoreys: 1; IsLandmarked: no

# IfcBuildingStorey, Piano 1
In: Edificio standard
Elevation: 0 mm
Pset_BuildingStoreyCommon - EntranceLevel: no; AboveGround: yes; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2

# IfcCovering: Laminated porcelain stoneware (UGL) (24)
In: Piano 1
Description: Porcelain stoneware tiles; PredefinedType: USERDEFINED; Material: Default
OtherThecnicalFeatures - AntibacterialProperties: Protect - test report available; ApparentDensity: 2,3 - 2,5 g/cm3; CompressionResistance: n/a; CrazingResistance: Pass; DeepAbrasionResistance: 175mm3; DimensionsLengthAndWidth: ± 0,3 %, max ± 1 mm; DimensionsRectangularity: ± 0,3 %, max ± 1,5 mm; DimensionsStraightness: ± 0,3 %, max ± 0,8 mm; DimensionsSurfaceFlatness: ± 0,4 %, max ± 1,8 mm; DimensionsThickness: ± 5 % ± 0,5mm; ElectricalConductivity: n/a; FrostResistance: Resistant; HardnessMohsScale: n/a; ImpactResistance: n/a; Light ReflectanceValueLRV: On request; LightAndColourFastness: Pass; LinearThermalExpansion: α ≤ 7·10-6 °C-1; ModulusOfRupture: 50 N/mm2; MoistureExpansion: n/a; PhotocatalyticProperties: n/a; StainsResistance: 5 RESISTANT; SurfaceAbrasionResistance: n/a; SurfaceQuality: n/a; ThermalConductivity: 1,3 W/m °K; TotalPorosity: n/a; WaterAbsorption: 0,1%
EnvironmentalSustainability - AsbestosFreeMaterial: yes; CAMCompliantDeclaration: On request (EPD); Ecolabel UE: no; EcolabelCertification: n/a; EMASCertification/Document: https://www.cottodeste.it/download#certificazioni; EnvironmentalProductDeclarationEPD: yes; EPDDocument: On request; EPDType: Product-Specific Type III EPD; FicheDeDéclarationEnvironnementaleEtSanitaireFDESCertification: n/a; FormaldehydeFreeMaterial: yes; HealthProductDeclarationHPDCertification/self declaration: On request; ISO45001Certification: n/a; ISO50001Certification: n/a; ISO9001Certification: https://www.cottodeste.it/download#certificazioni; RawMaterialSourceAndExtractionDocument: On request; REACHCompliant: yes; RecyclableProductPackaging: yes; RecycledContentPreconsumerCertification: https://www.cottodeste.it/download#certificazioni; SolarReflectance_After3YearValue: On request; SolarReflectance_InitialValue: On request; SolarReflectanceCertification: n/a; SolarReflectanceIndexSRICertification: On request; VOCIndoorAirQualityCertification: On request; ZeroVOCMineralBasedProduct: yes
DoP&ProductCertification - BondStrengthAdhesion: NPD; BreakingStrength: ≥ 700 N; CEMarking: yes; CertificateNumber: n/a; DeclarationPerformanceNumber: DOP005EST; DurabilityExternalUseFreezeThawResistance: Passed; DurabilityForInternalUse: Passed; HarmonizedTechnicalSpecification: EN 14411:2012; Intended Use: Ceramic tiles for internal flooring and internal and external wall applications, pre-assembled on a fibreglass mesh.; NameAndIdentificationNumberOfNotifiedLaboratory: n/a; ReactionToFire: A2fl-s1/A1-s1,d0; ReleaseOfDangerousSubstanceCadmium: NPD; ReleaseOfDangerousSubstanceLead: NPD; SlipperinessBS7976-2_PendulumTester: n/a; SlipperinessDIN51097_RampBarefoot: n/a; SlipperinessDIN51131_Tribometer: n/a; SlipperinessENV12633_PendulumTester: n/a; SlipperinessXPCENTS16165_RampTest: n/a; SystemOfAssessmentAndVerificationOfCostancyOfPperformance: System 4; Tactility: NPD; TensileStrengthOrModulusOfRupture: 50 N/mm2; ThermalShockResistance: Pass; UNIMark: no; UNIMarkCertification: On request; UniqueIdentificationCodeOfTheProductType: Dry-pressed ceramic tiles,with water absorption Eb<0,5%
COBie_ServiceLife - ExpectedLife: 50
COBie_EconomicImpactValues - ReplacementCost: 0
COBie_Component - InstallationDate: 31/12/1900 23:59:59; WarrantyStartDate: n/a; TagNumber: n/a; AssetIdentifier: n/a
Pset_CoveringFlooring - HasNonSkidSurface: yes; HasAntiStaticSurface: no
Pset_Condition - AssessmentDate: 31/12/1900 23:59:59; AssessmentCondition: n/a; AssessmentDescription: n/a
Pset_CoveringCommon - Reference: Laminated porcelain stoneware (UGL); AcousticRating: n/a; FlammabilityRating: Class A2-s1, do (wall) ; Class A2fl-s1 (floor); FragilityRating: n/a; Combustible: no; SurfaceSpreadOfFlame: Class A; IsExternal: no; ThermalTransmittance: 216 W/K/m2; FireRating: Class A2-s1, do (wall) ; Class A2fl-s1 (floor)
COBie_Asset - AssetType: Fixed
COBie_Specification - NominalWidth: 1200 mm; NominalHeight: 6.5 mm; Grade: n/a; Material: Porcelain stoneware tile; Constituents: n/a; Features: n/a; AccessibilityPerformance: n/a; CodePerformance: n/a; SustainabilityPerformance: n/a
COBie_Warranty - WarrantyGuarantorParts: n/a; WarrantyDurationParts: 0; WarrantyGuarantorLabor: n/a; WarrantyDurationLabor: 0; WarrantyDescription: n/a
Pset_ManufacturerTypeInformation - GlobalTradeItemNumber: n/a; ModelReference: Lithos Kerlite 6Plus; Manufacturer: Cotto d'Este (Panariagroup Industrie Ceramiche S.p.A.); ProductionYear: n/a
Pset_EnvironmentalImpactIndicators - Reference: Laminated porcelain stoneware (UGL); FunctionalUnitReference: 1 mq (m2); Unit: 1 mq (m2); LifeCyclePhase: Manufacture; ExpectedServiceLife: 50 s; TotalPrimaryEnergyConsumptionPerUnit: 225; WaterConsumptionPerUnit: 0.054 m3; HazardousWastePerUnit: 0.00235 g; NonHazardousWastePerUnit: 1.62 g; ClimateChangePerUnit: 10.7 g; AtmosphericAcidificationPerUnit: 0.0254 g; RenewableEnergyConsumptionPerUnit: 46; NonRenewableEnergyConsumptionPerUnit: 179; ResourceDepletionPerUnit: 0.000075 g; InertWastePerUnit: 0 g; RadioactiveWastePerUnit: 0.00393 g; StratosphericOzoneLayerDestructionPerUnit: 0 g; PhotochemicalOzoneFormationPerUnit: 0.00232 g; EutrophicationPerUnit: 0.00358 g
Pset_EnvironmentalImpactValues - TotalPrimaryEnergyConsumption: 0; WaterConsumption: 0 m3; HazardousWaste: 0 g; NonHazardousWaste: 0 g; ClimateChange: 0 g; AtmosphericAcidification: 0 g; RenewableEnergyConsumption: 0; NonRenewableEnergyConsumption: 0; ResourceDepletion: 0 g; InertWaste: 0 g; RadioactiveWaste: 0 g; StratosphericOzoneLayerDestruction: 0 g; PhotochemicalOzoneFormation: 0 g; Eutrophication: 0 g; LeadInTime: 0; Duration: 0; LeadOutTime: 0
Pset_ServiceLife - ServiceLifeDuration: 50; MeanTimeBetweenFailure: n/a
Pset_Warranty - WarrantyIdentifier: n/a; WarrantyStartDate: 31/12/1900 23:59:59; WarrantyEndDate: 31/12/1900 23:59:59; IsExtendedWarranty: no; WarrantyPeriod: n/a; WarrantyContent: n/a; PointOfContact: n/a; Exclusions: n/a
COBie - BarCode: n/a; Category: Pr_35_93_96_19:Ceramic tiles; Description: Stone Effect; DurationUnit: Year; Manufacturer: Cotto d'Este (Panariagroup Industrie Ceramiche S.p.A.); ModelNumber: n/a; ModelReference: Lithos Kerlite 6Plus; SerialNumber: n/a; WarrantyDurationUnit: Year
Name | ChemicalResistance | SlipperinessBCRA_Tribometer | SlipperinessBOT3000_Tribometer | SlipperinessDIN51130_RampWithOil | UPECmark | UPECMarkCertification | Pset_CoveringCommon, Finish = COBie_Specification, Finish | NominalLength (mm) | Shape | Size | Color | ArticleNumber | ModelLabel | Name
Lithos Kerlite 6Plus Carbon Nat Ret 120x120 | LA, HA RESISTANT | μ > 0,40 | DCOF ≥ 0.42 | R10 | no | n/a | Natural Rectified | 1200 | Square | 1200x1200x6.5 mm | Carbon | EK8LT00 | Carbon Natural | Carbon Natural Ret 120x120
Lithos Kerlite 6Plus Moon Nat Ret 120x260 | LA, HA RESISTANT | μ > 0,40 | DCOF ≥ 0.42 | R10 | no | n/a | Natural Rectified | 2600 | Rectangular | 2600x1200x6.5 mm | Moon | EK7LT20 | Moon Natural | Moon Natural Ret 120x260
Lithos Kerlite 6Plus Moon Soft Ret 120x260 | LB, HB | NPD | NPD | NPD | no | n/a | Soft Rectified | 2600 | Rectangular | 2600x1200x6.5 mm | Moon | EK7LT25 | Moon Soft | Moon Soft Ret 120x260
Lithos Kerlite 6Plus Desert Nat Ret 120x260 | LA, HA RESISTANT | μ > 0,40 | DCOF ≥ 0.42 | R10 | no | n/a | Natural Rectified | 2600 | Rectangular | 2600x1200x6.5 mm | Desert | EK7LT10 | Desert Natural | Desert Natural Ret 120x260
Lithos Kerlite 6Plus Desert Soft Ret 120x260 | LB, HB | NPD | NPD | NPD | no | n/a | Soft Rectified | 2600 | Rectangular | 2600x1200x6.5 mm | Desert | EK7LT15 | Desert Soft | Desert Soft Ret 120x260
Lithos Kerlite 6Plus Stone Nat Ret 120x260 | LA, HA RESISTANT | μ > 0,40 | DCOF ≥ 0.42 | R10 | no | n/a | Natural Rectified | 2600 | Rectangular | 2600x1200x6.5 mm | Stone | EK7LT30 | Stone Natural | Stone Natural Ret 120x260
Lithos Kerlite 6Plus Stone Soft Ret 120x260 | LB, HB | NPD | NPD | NPD | no | n/a | Soft Rectified | 2600 | Rectangular | 2600x1200x6.5 mm | Stone | EK7LT35 | Stone Soft | Stone Soft Ret 120x260
Lithos Kerlite 6Plus Carbon Nat Ret 120x260 | LA, HA RESISTANT | μ > 0,40 | DCOF ≥ 0.42 | R10 | no | n/a | Natural Rectified | 2600 | Rectangular | 2600x1200x6.5 mm | Carbon | EK7LT00 | Carbon Natural | Carbon Natural Ret 120x260
Lithos Kerlite 6Plus Carbon Soft Ret 120x260 | LB, HB | NPD | NPD | NPD | no | n/a | Soft Rectified | 2600 | Rectangular | 2600x1200x6.5 mm | Stone | EK7LT05 | Carbon Soft | Stone Soft Ret 120x260
Lithos Kerlite 6Plus Moon Nat Ret 120x120 | LA, HA RESISTANT | μ > 0,40 | DCOF ≥ 0.42 | R10 | no | n/a | Natural Rectified | 1200 | Square | 1200x1200x6.5 mm | Moon | EK8LT20 | Moon Natural | Moon Natural Ret 120x120
Lithos Kerlite 6Plus Moon Soft Ret 120x120 | LB, HB | NPD | NPD | NPD | no | n/a | Soft Rectified | 1200 | Square | 1200x1200x6.5 mm | Moon | EK8LT25 | Moon Soft | Moon Soft Ret 120x120
Lithos Kerlite 6Plus Desert Nat Ret 120x120 | LA, HA RESISTANT | μ > 0,40 | DCOF ≥ 0.42 | R10 | no | n/a | Natural Rectified | 1200 | Square | 1200x1200x6.5 mm | Desert | EK8LT10 | Desert Natural | Desert Natural Ret 120x120
Lithos Kerlite 6Plus Desert Soft Ret 120x120 | LB, HB | NPD | NPD | NPD | no | n/a | Soft Rectified | 1200 | Square | 1200x1200x6.5 mm | Desert | EK8LT15 | Desert Soft | Desert Soft Ret 120x120
Lithos Kerlite 6Plus Stone Nat Ret 120x120 | LA, HA RESISTANT | μ > 0,40 | DCOF ≥ 0.42 | R10 | no | n/a | Natural Rectified | 1200 | Square | 1200x1200x6.5 mm | Stone | EK8LT30 | Stone Natural | Stone Natural Ret 120x120
Lithos Kerlite 6Plus Stone Soft Ret 120x120 | LB, HB | NPD | NPD | NPD | no | n/a | Soft Rectified | 1200 | Square | 1200x1200x6.5 mm | Stone | EK8LT35 | Stone Soft | Stone Soft Ret 120x120
Lithos Kerlite 6Plus Carbon Soft Ret 120x120 | LB, HB | NPD | NPD | NPD | no | n/a | Soft Rectified | 1200 | Square | 1200x1200x6.5 mm | Stone | EK8LT05 | Carbon Soft | Stone Soft Ret 120x120
Lithos Kerlite 6Plus Carbon Nat Ret 60x120 | LA, HA RESISTANT | μ > 0,40 | DCOF ≥ 0.42 | R10 | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | Natural Rectified | 600 | Rectangular | 600x1200x6.5 mm | Carbon | EKXLT00 | Carbon Natural | Carbon Natural Ret 60x120
Lithos Kerlite 6Plus Moon Nat Ret 60x120 | LA, HA RESISTANT | μ > 0,40 | DCOF ≥ 0.42 | R10 | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | Natural Rectified | 600 | Rectangular | 600x1200x6.5 mm | Moon | EKXLT20 | Moon Natural | Moon Natural Ret 60x120
Lithos Kerlite 6Plus Moon Soft Ret 60x120 | LB, HB | NPD | NPD | NPD | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | Soft Rectified | 600 | Rectangular | 600x1200x6.5 mm | Moon | EKXLT25 | Moon Soft | Moon Soft Ret 60x120
Lithos Kerlite 6Plus Desert Nat Ret 60x120 | LA, HA RESISTANT | μ > 0,40 | DCOF ≥ 0.42 | R10 | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | Natural Rectified | 600 | Rectangular | 600x1200x6.5 mm | Desert | EKXLT10 | Desert Natural | Desert Natural Ret 60x120
Lithos Kerlite 6Plus Desert Soft Ret 60x120 | LB, HB | NPD | NPD | NPD | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | Soft Rectified | 600 | Rectangular | 600x1200x6.5 mm | Desert | EKXLT15 | Desert Soft | Desert Soft Ret 60x120
Lithos Kerlite 6Plus Stone Nat Ret 60x120 | LA, HA RESISTANT | μ > 0,40 | DCOF ≥ 0.42 | R10 | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | Natural Rectified | 600 | Rectangular | 600x1200x6.5 mm | Stone | EKXLT30 | Stone Natural | Stone Natural Ret 60x120
Lithos Kerlite 6Plus Stone Soft Ret 60x120 | LB, HB | NPD | NPD | NPD | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | Soft Rectified | 600 | Rectangular | 600x1200x6.5 mm | Stone | EKXLT35 | Stone Soft | Stone Soft Ret 60x120
Lithos Kerlite 6Plus Carbon Soft Ret 60x120 | LB, HB | NPD | NPD | NPD | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | Soft Rectified | 600 | Rectangular | 600x1200x6.5 mm | Stone | EKXLT05 | Carbon Soft | Stone Soft Ret 60x120
